## base_external/package/temp/Config.in
```kconfig
config BR2_PACKAGE_TEMP
	bool "TEMP"
	help
	  Includes the TEMP PACKAGE
	  Used to Use temp_load temp_unload modules
```
